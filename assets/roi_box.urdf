Commit message: wip

File: assets/roi_box.urdf (robot description, URDF)
Before this commit: robot roi_box, 2 links, 1 joints
Links:
- link roi_box: geometry visual box size=0.3 0.19 0.7
