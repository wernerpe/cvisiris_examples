Commit message: 7dof_example collision trajectory

File: assets/ground_big.urdf (robot description, URDF)
Before this commit: robot ground, 2 links, 1 joints
Links:
- link lid: geometry collision box size=4.0 0.1 4.0; visual box size=4.0 0.1 4.0
